# Keil uVision project STMFLASH.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STMFLASH +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\STMFLASH;..\HARDWARE\CMT211xA;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\CC110x;..\HARDWARE\ENCODE_DECODE;..\Libs;..\Console;..\USMART;..\PRO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/CMT211xA/: CMT211xA.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CC110x/: CC110x.c
    ../HARDWARE/ENCODE_DECODE/: encode_decode.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c
  group README
    ../: README.TXT
  group Libs
    ../Libs/: libsz.lib
  group Console
    ../Console/: console_cmd.c stm_console.c
  group PRO
    ../PRO/: pro.c
